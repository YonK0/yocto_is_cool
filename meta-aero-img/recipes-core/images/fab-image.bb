DESCRIPTION = "Custom Fab image"
LICENSE = "CLOSED"

require core-base-image.inc

#Using fab distro conf
IMAGE_TYPE = "fab"
